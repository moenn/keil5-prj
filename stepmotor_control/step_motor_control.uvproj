# Keil uVision project step_motor_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: step_motor_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: step_motor_control.c
